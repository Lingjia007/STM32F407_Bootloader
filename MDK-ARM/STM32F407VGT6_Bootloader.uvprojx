# Keil uVision project STM32F407VGT6_Bootloader.uvprojx, settings and files
target STM32F407VGT6_Bootloader (6210000::V6.21::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407VGT6_Bootloader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../LED;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bootloader_Core;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../IAP;../Middlewares/Third_Party/LittleFs;../Utils;../ESP8266_OTA;../Platform/Inc;../Impl/Inc;../Service/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\STM32F407VGT6_Bootloader\STM32F407VGT6_Bootloader.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c rng.c rtc.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group IAP
    ../IAP/: menu.c ymodem.c
  group LED
    ../LED/: led.c
  group Platform
    ../Platform/Src/: platform_config.c
  group Impl
    ../Impl/Src/: platform_gpio_led_stm32_impl.c platform_pwm_led_stm32_impl.c platform_w25q128_stm32_impl.c platform_internal_flash_stm32_impl.c platform_fatfs_stm32_impl.c platform_lfs_stm32_impl.c platform_uart_stm32_impl.c platform_filesystem_fatfs_impl.c platform_filesystem_lfs_impl.c platform_rtc_stm32_impl.c platform_wifi_esp8266_impl.c platform_mqtt_esp8266_impl.c platform_tick_stm32_impl.c
  group Service
    ../Service/Src/: service_notify.c service_lfs_spi_flash_adapter.c service_ymodem.c service_menu.c service_hpatch.c service_wifi_transport.c service_onenet_ota.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Bootloader_Core
    ../Bootloader_Core/: bootloader_core.c firmware_package.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/LittleFs
    ../Middlewares/Third_Party/LittleFs/: lfs.c lfs_util.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Utils
    ../Utils/: aes.c bsdiff.c bspatch.c hkdf.c hpatch_lite.c tuz_dec.c cJSON.c md5.c c25519.c ecdsa.c ed25519.c edsign.c f25519.c fprime.c morph25519.c sha512.c
    ../Service/Src/: service_aes_decrypt.c service_ed25519_verify.c
  group ESP8266_OTA
    ../ESP8266_OTA/: esp8266_ota_api.c
software components: CMSIS:CORE 6.1.0
